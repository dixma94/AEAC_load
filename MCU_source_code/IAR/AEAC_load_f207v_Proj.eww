<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\AEAC_load_f207v_Proj.ewp</path>
  </project>
  <batchBuild/>
</workspace>


