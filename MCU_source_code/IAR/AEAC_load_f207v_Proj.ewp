# IAR project AEAC_load_f207v_Proj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207VE ST STM32F207VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\Libraries\CMSIS\Device\ST\STM32F2xx\Include; ..\Libraries\CMSIS\Include; ..\Libraries\STM32F2xx_HAL_Driver\Inc; inc; src; ModBus
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AEAC_load_f207v_Proj.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: D:\IvanovD\Documents\AEAC_Load\MCU_source_code\IAR\stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    src/: main.c
  group CMSIS
    ../Libraries/CMSIS/Core/Include/: core_cm3.h
    ./: startup_stm32f207xx.s
    ../Libraries/CMSIS/Device/ST/STM32F2xx/Include/: stm32f207xx.h
    src/: system_stm32f2xx.c
  group HAL_Driver
    ../Libraries/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dac.c stm32f2xx_hal_dma.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_iwdg.c stm32f2xx_hal_rcc.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_uart.c
  group inc
    inc/: BoardConfig.h stm32f2xx_hal_conf.h
  group MODBUS
    ModBus/: MODBUS.c MODBUS_CRC.c MODBUS_FUNC.c MODBUS_TIMEOUT.c
    src/: UART_Driver.c
  group src
    src/: Alg_FUNC.c BoardConfig.c CurrentSet_FUNC.c FAN_FUNC.c Impedance_FUNC.c IWDG.c Measure_FUNC.c SaveReadConfigurationToFlashMCU.c stm32f2xx_it.c
